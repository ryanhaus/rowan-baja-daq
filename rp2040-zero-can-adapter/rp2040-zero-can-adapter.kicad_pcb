# Repository ryanhaus/rowan-baja-daq

File README.md:

# Rowan University Baja DAQ System
This repository contains all files related to the Data Acqusition (DAQ) system for Rowan University's Baja SAE 2025-2027 team.

All files in this repository are licensed under the [GNU General Public License Version 3.0](LICENSE).

## Components
Click these links to quickly navigate to one of the several components of the DAQ system.
Each link has more detailed information about the design and use of the component.
 - [CAN Module](can-module): Main building block of design, connects other devices together over the CAN bus.

 - [Accelerometer Board](accelerometer-board): Contains a 6-axis intertial measurement unit to measure linear and rotational acceleration.

 - [SD Card Board](sd-card-board): Contains a microSD card slot to log data.

 - [Wireless Communication Unit](comm-unit): Contains a LoRa module to wirelessly transmit data.

 - [PMOD Adapter](pmod-adapter): Allows PMOD boards to be attached to the CAN Modules.

## KiCad design rp2040-zero-can-adapter/rp2040-zero-can-adapter.kicad_pcb

Parts:
C2: 1u; C_0603_1608Metric
D1: SMAJ5.0CA; D_SMA
F1: 0805L050WR; Fuse_0805_2012Metric
J1: CONN_PI_PWR; PinSocket_1x03_P2.54mm_Vertical
J2: CONN_PI_GPIO; PinSocket_1x03_P2.54mm_Vertical
J3: CONN_EXT; PinSocket_1x04_P2.54mm_Vertical
Q1: SL2305S; SOT-23
R1, R2, R3: 0; R_0603_1608Metric; not fitted
U1: PESD2CANFD27LU-QX; SOT-23-3
U3: ATA6561-GAQW-N; SOIC127P600X175-8N; Manufacturer_Part_Number ATA6561-GAQW-N; Mouser Part Number 579-ATA6561-GAQW-N

Connections:
+3V3: J1.1, R1.1, U3.5 (VIO)
+5V: C2.1, J1.3, Q1.3 (S), R3.1, U3.3 (VCC)
/CANH: J3.2, U1.2 (K2), U3.7 (CANH)
/CANL: J3.1, U1.1 (K1), U3.6 (CANL)
/PI_GPIO0: J2.3, U3.4 (RXD)
/PI_GPIO1: J2.2, U3.1 (TXD)
/PI_GPIO2: J2.1, U3.8 (STBY)
GND: C2.2, D1.1 (A1), J1.2, J3.3, Q1.2 (G), R2.1, U1.3 (CC), U3.2 (GND)
unnamed: D1.2 (A2), F1.2, Q1.1 (D)
VBUS: F1.1, J3.4

Notes on the sheet:
500 mA
CAN Transceiver
Cross-Board Power Jumpers
Connectors
ESD, Reverse Bias, and Short Protection
Would daisy-chain to another board

Board: 2 copper layers, 18.0 x 9.0 mm, 12 parts (6 on the bottom side), 10 nets.

## KiCad design can-module/pcb/can-module.kicad_pcb

File can-module/pcb/README.md:

# PCB
The CAN Module is a 1" x 0.75" printed circuit board (PCB) designed in [KiCad](https://kicad.org). All KiCad files are available in the '[pcb](pcb)' directory.

The board features a [48MHz PIC32 microcontroller](#microcontroller), a [CAN Transceiver](#can-transceiver), [headers for power and CAN communication](#vehicle-interface), as well as [8 GPIO pins](#sensor-interface).

Below shows an orthographic top and bottom view of the board:

<div align="center">

</div>

> [!NOTE]
> If more than 8 GPIO pins are required for a particular sensor or module, an I2C GPIO expander can be used, or wires can be soldered to one of the exposed GPIO test points (see [here](#extra-gpios)).
> Alternatively, a larger custom board can be designed, these modules are able to communicate with any CAN-FD compatible device that communicates with a 5V logic level.

## Schematic
A schematic of the CAN Module is shown below.
Higher-quality pdf available [here](../assets/schematic.pdf).

## Dimensions
The dimensions below may be of use for designing custom enclosures or daughterboards to be mounted to the CAN Module.
All dimensions are in mm, and the mounting holes are M2. Additionally, the pin headers have 0.05" (1.27mm) hole spacing.

## Power Requirements
The boards should be powered with +5V DC through the appropriate pins in the [vehicle interface](#vehicle-interface).

The total power consumption depends on attached sensors and modules, but 100-200 mA at most will be consumed by the board itself during peak power usage.

> [!NOTE]
> The boards feature reverse polarity protection, a resettable fuse, and ESD protection diodes on all pins within the vehicle interface.

## Microcontroller
The microcontroller on the CAN Module is the [PIC32CM1216JH01048-I/U5B](https://www.digikey.com/en/products/detail/microchip-technology/PIC32CM1216JH01048-I-U5B/25904014), an inexpensive and tiny 32-bit ARM microcontroller that operates at 48MHz with 128KB of flash and 16KB of RAM, as well as an embedded hardware CAN controller.
See the datasheet [here](https://ww1.microchip.com/downloads/aemDocuments/documents/MCU32/ProductDocuments/DataSheets/PIC32CM-JH00-JH01-Family-Data-Sheet-DS60001632.pdf).

## CAN Transceiver
The CAN Transceiver on the CAN Module is the [ATA6560-GBQW-N](https://www.digikey.com/en/products/detail/microchip-technology/ATA6560-GBQW-N/9453100?s=N4IgTCBcDaIIIBU4DYCsyAMBaA4gIQEUB1LAORAF0BfIA).
See the datasheet [here](https://ww1.microchip.com/downloads/en/DeviceDoc/20005991B.pdf).

## Indication LEDs
There are two indication LEDs present on the CAN Module.
One LED is a power indicator LED and is not configurable.
The other is configurable and has the cathode connected through a 30k resistor to the PA12 pin on the microcontroller.
Each LED has 5V at the anode.

## Pins & Connectors
All pins on the CAN Module operate at 5V logic levels by default.
There are two distinct sets of pins on the board that serve different purposes, the sensor interface and the vehicle interface, as described and labelled below.

<div align="center">
    
</div>

> [!WARNING]
> The headers use **0.05" (1.27mm) hole spacing** for space conservation, not the more common 0.1" (2.54mm) spacing.

### Sensor Interface
The sensor interface is the set of 8 GPIO and 2 output power pins located on the left side of the board.
These pins are intended to provide power to and communicate with some sensor or module, or a custom-designed daughterboard which mounts on top of the CAN Module PCB.

There are two distinct pin headers in the sensor interface, one being 2 pins, and the other being 8 pins.
These are the output power and communication headers, respectively.

The output power header has a positive pin (+5V) and a negative pin (GND), which is labelled appropriately on the board.

The communication header has 8 GPIO pins which are directly connected to GPIO pins on the [microcontroller](#microcontroller).
The pins included in this header include GPIO pins PA4 through PA11 from the microcontroller in sequential order, as labelled on the board.
These pins were selected because every one of them is capable of acting as a communication interface pin for the SERCOM peripheral on the microcontroller, see the [datasheet](https://ww1.microchip.com/downloads/aemDocuments/documents/MCU32/ProductDocuments/DataSheets/PIC32CM-JH00-JH01-Family-Data-Sheet-DS60001632.pdf) (Table 4-2) for more info.

> [!WARNING]
> These pins do not have ESD diodes, series resistors, or short circuit protection (other than what is provided by the microcontroller's GPIO pins).

> [!NOTE]
> Some of these pins are powered by AVDD and some are powered by VDD<sub>IO</sub>.
> While VDD<sub>IO</sub> can be changed to 3.3V to use 3.3V logic, AVDD must remain 5V.
> A future revision of this board could take this into consideration and only expose pins powered by VDD<sub>IO</sub>, so that 3.3V logic can be achieved without external logic level converters.
> Another solution could be to power the entire chip by 3.3V and use an ATA6561 instead of the ATA6560, since the former is able to communicate with 3.3V microcontrollers.

### Vehicle Interface
The vehicle interface is the set of 2 communication and 2 input power pins located on the right side of the board.
These pins are intended to provide power to the CAN Module board and allow for communication between the board and the rest of the vehicle via the shared CAN Bus.

The pins are organized as a single 4-pin header.

### Extra GPIOs
13 extra GPIO pins are exposed from the microcontroller and can be used.
See the screenshot below to see all labelled test points.

<div align="center">
    
</div>

> [!NOTE]
> All GPIO test points are exposed from Port A, so it is not explicitly labelled in the screenshot.
> For example, the point labelled '13' maps to PA13, '14' to PA14, etc.

> [!NOTE]
> In addition to GPIOs, there is also a test point for +5V.
> This test point is after all power filtering & fusing, so it may be helpful for debugging power issues.

### Programming/Debug Pins
Two serial-wire debug (SWD) pins are exposed and labelled on the back of the board.
A SWD-capable interface will be required to program the boards.

> [!NOTE]
> This is TBD, the boards have not been manufactured yet.

## Connecting to Other Modules
In order to interface with other devices (i.e., other CAN Modules), they must be wired on the same shared CAN Bus.
An example layout is shown below:

Note that every module shares the same four wires that are routed throughout the vehicle.
This topology helps significantly reduce the amount of wire required, time spent routing wire, and helps decentralize devices to minimize single points of failure.

Also note that CAN Bus Modules generally do not exist on their own, they will probably need some other attached device or sensor to either provide or process data on the bus.

See [here](https://en.wikipedia.org/wiki/CAN_bus) for more info on CAN Bus.

> [!WARNING]
> Make sure that the CAN bus is properly terminated, see [here](https://support.maxongroup.com/hc/en-us/articles/360009241840-CAN-bus-topology-and-bus-termination) for more info.

## Updating This Project
After changes are made to the project, [KiBot](https://github.com/INTI-CMNB/KiBot) (must be installed) can be used to automatically create renders of the schematic and PCB used in this documentation.

Navigate to the `pcb` directory, and run the following:
```sh
$ kibot
```

This command will automatically run the DRC and generate renders.
See [`can-module.kibot.yaml`](pcb/can-module.kibot.yaml) for the configuration.

Parts:
C1, C4, C6, C8, C10, C12, C13: 10u; C_0402_1005Metric
C2, C3, C5, C7, C9, C11, C14: 100n; C_0402_1005Metric
D1, D2, D3: DESD5V0U1BA-7; D_SOD-323
D4, D5: LTST-C170GKT; LED_0805_2012Metric
F1: 1206L050YR; Fuse_1206_3216Metric
J1: Conn_01x04_Socket; PinHeader_1x04_P1.27mm_Vertical
J2, J4: Conn_01x02_Socket; PinHeader_1x02_P1.27mm_Vertical
J3: Conn_01x08_Socket; PinHeader_1x08_P1.27mm_Vertical
R1, R3, R4: 30k; R_0402_1005Metric
R2: 100k; R_0402_1005Metric
R5: 1k; R_0402_1005Metric
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14: TestPoint; TestPoint_Pad_D1.0mm_TightSpacing
U1: PIC32CM1216JH01048-I_U5B; QFN50P700X700X90-49N-D; Manufacturer_Part_Number PIC32CM1216JH01048-I/U5B
U2: NID5100GWH; Manufacturer_Part_Number NID5100GWH; Mouser Part Number 771-NID5100GWH
U3: ATA6560-GBQW-N; VDFN8_3X3_MCH

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C12.1, C13.1, C14.1, D4.2 (A), J4.2, R2.1, R3.1, R4.1, R5.2, TP14.1, U1.6 (AVDD), U1.17 (VDDIO_1), U1.36 (VDDIO_2), U1.44 (VDDIN), U2.6 (OUT), U3.3 (VCC)
/PA04: J3.8, U1.9 (PA04)
/PA05: J3.7, U1.10 (PA05)
/PA06: J3.6, U1.11 (PA06)
/PA07: J3.5, U1.12 (PA07)
/PA08: J3.4, U1.13 (PA08)
/PA09: J3.3, U1.14 (PA09)
/PA10: J3.2, U1.15 (PA10)
/PA11: J3.1, U1.16 (PA11)
/SWCLK: J2.1, R5.1, U1.45 (PA30_SWCLK)
/SWDIO: J2.2, U1.46 (PA31_SWDIO)
CANH: D2.2 (A2), J1.2, U3.7 (CANH)
CANL: D1.2 (A2), J1.1, U3.6 (CANL)
CAN_NSIL: U1.32 (PA23), U3.5 (NSIL)
CAN_RX: U1.34 (PA25), U3.4 (RXD)
CAN_STBY: U1.31 (PA22), U3.8 (STBY)
CAN_TX: U1.33 (PA24), U3.1 (TXD)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, D1.1 (A1), D2.1 (A1), D3.1 (A1), D5.1 (K), J1.3, J4.1, U1.5 (AVSS), U1.18 (GND_1), U1.35 (GND_2), U1.42 (GND_3), U1.49 (EP), U2.2 (GND), U2.3 (~EN), U3.2 (GND), U3.9 (EPAD)
unnamed: D4.1 (K), R1.2
unnamed: D5.2 (A), R4.2
unnamed: TP1.1, U1.1 (PA00_XIN32)
unnamed: TP2.1, U1.2 (PA01_XOUT32)
unnamed: TP3.1, U1.3 (PA02)
unnamed: TP4.1, U1.4 (PA03)
unnamed: R1.1, U1.21 (PA12)
unnamed: TP5.1, U1.22 (PA13)
unnamed: TP6.1, U1.23 (PA14_XIN)
unnamed: TP7.1, U1.24 (PA15_XOUT)
unnamed: TP13.1, U1.25 (PA16)
unnamed: TP12.1, U1.26 (PA17)
unnamed: TP11.1, U1.27 (PA18)
unnamed: TP10.1, U1.28 (PA19)
unnamed: TP9.1, U1.29 (PA20)
unnamed: TP8.1, U1.30 (PA21)
unnamed: C11.1, R2.2, U1.40 (~RESET)
unnamed: C10.1, F1.2, U2.1 (IN)
unnamed: R3.2, U2.5 (ST)
VDD_{CORE}: C8.1, C9.1, U1.43 (VDDCORE)
VIN: D3.2 (A2), F1.1, J1.4

Notes on the sheet:
1x decoupling cap for each power pin
Sensor Interface Connectors
Vehicle Interface Connector
MCU Decoupling Capacitors
Power Header
Power Filtering & Protection
CAN Transceiver
1x bulk cap for each AVDD, VDDIO, VDDIN, VDDCORE
PIC32 MCU
Programming/Debug Header
GPIO Header

Board: 2 copper layers, 25.4 x 19.0 mm, 46 parts (0 on the bottom side), 39 nets.

## KiCad design sd-card-board/pcb/sd-card-board.kicad_pcb

File sd-card-board/README.md:

# SD Card Board
This board is a small data logger board that is designed to mount as a daughterboard for the [CAN Module](../can-module).
A microSD card can be inserted into it and the CAN Module will be able to communicate with the card.
The board features a 5V <=> 3.3V logic level converter to allow communication between the CAN Module and the microSD card.

> [!NOTE]
> The SD card will be operating in SPI mode, so data bandwidth will be somewhat limited.

## Schematic
A screenshot of the schematic is below, a higher-quality pdf is available [here](assets/schematic.pdf).

## Pins
| CAN Module | SD Card Board |
| ---------- | ------------- |
| A4         | N/C           |
| A5         | N/C           |
| A6         | N/C           |
| A7         | N/C           |
| A8         | CSn           |
| A9         | DI            |
| A10        | CLK           |
| A11        | DO            |

Parts:
C1, C2: 1u; C_0402_1005Metric
J1: Conn_01x08; PinSocket_1x08_P1.27mm_Vertical
J2: Conn_01x02; PinSocket_1x02_P1.27mm_Vertical
J3: 1051620001; 105162-0001_MOL
U1: MIC5365-3.3YC5-TR; SOT-353_SC-70-5
U2: FXMAR2104UMX; ULTRATHIN_MLP_12L_ONS

Connections:
+3V3: C2.1, J3.4 (VDD), U1.5 (VOUT), U2.1 (VCCB)
+5V: C1.1, J2.2, U1.1 (VIN), U1.3 (EN), U2.2 (VCCA), U2.8 (OE)
/MCU_CLK: J1.2, U2.4 (A1)
/MCU_DI: J1.3, U2.5 (A2)
/MCU_DO: J1.1, U2.3 (A0)
/SD_CLK: J3.5 (CLK), U2.11 (B1)
/SD_DI: J3.3 (CMD), U2.10 (B2)
/SD_DO: J3.7 (DAT0), U2.12 (B0)
/~MCU_CS: J1.4, U2.6 (A3)
/~SD_CS: J3.2 (DAT3/CD), U2.9 (B3)
GND: C1.2, C2.2, J2.1, J3.6 (VSS), J3.9 (SHIELD), U1.2 (GND), U2.7 (GND)

Notes on the sheet:
MicroSD Card Slot
Power Input
5V <=> 3.3V Level Shifter
Card is used in SPI Mode
5V to 3.3V Conversion
GPIO

Board: 2 copper layers, 22.9 x 19.1 mm, 7 parts (2 on the bottom side), 11 nets.

## KiCad design pmod-adapter/pcb/pmod-adapter.kicad_pcb

File pmod-adapter/README.md:

# PMOD Adapter
The PMOD adapter is meant to be a daughterboard for the [CAN Module](../can-module).
It is meant to act as an adapter board to convert the 5V logic from the CAN Module into 3.3V logic for the [PMOD interface](https://en.wikipedia.org/wiki/Pmod_Interface) (see the spec [here](https://digilent.com/reference/_media/reference/pmod/pmod-interface-specification-1_2_0.pdf?srsltid=AfmBOopyBuaw-eLZASs9BrwRv7mYRkTEZ4E9nGXd7mhXq3Ivtdyv9wY3)), which is commonly used in many [Digilent sensor boards](https://digilent.com/shop/products/fpga-boards/expansion-modules/pmods).
This helps save time when a single sensor needs to be used and it would be impractical to design a custom board just for that, making it easier to simply plug in a PMOD board.

## Schematic
Screenshot of schematic is below. Higher quality pdf available [here](assets/schematic.pdf).

## Pins
| CAN Module | PMOD Adapter |
| ---------- | ------------ |
| A4         | PMOD 0       |
| A5         | PMOD 1       |
| A6         | PMOD 2       |
| A7         | PMOD 3       |
| A8         | PMOD 4       |
| A9         | PMOD 5       |
| A10        | PMOD 6       |
| A11        | PMOD 7       |

## Extra Information
### Mounting to CAN Module
This board can mount directly onto the sensor interface of the CAN Module via female headers on the bottom of the board.
Note that, due to size constraints, this board does not feature M2 mounting holes.

### Changing the Logic Level
This board supports changing the logic level via a selectable solder bridge on the bottom of the board.
See the top right in the screenshot below:

> [!CAUTION]
> Note: When switching the logic level to 5V or something else, note that **the 3.3V bridge will have to be disconnected!!** Otherwise, this bridge will dead-short 5V to 3.3V.

Parts:
C1, C2, C3: 1u; C_0402_1005Metric
C4, C5: 100n; C_0402_1005Metric
J1: Conn_01x08; PinSocket_1x08_P1.27mm_Vertical
J2: Conn_01x02; PinSocket_1x02_P1.27mm_Vertical
J3: Conn_02x06_Top_Bottom; PinSocket_2x06_P2.54mm_Horizontal
JP1: SolderJumper_3_Bridged12; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
R1, R2, R3, R4, R5, R6, R7, R8: 200; R_0402_1005Metric
U1: FXMA108BQX; WQFN-20-1EP_2.5x4.5mm_P0.5mm_EP1x2.9mm
U2: MIC5365-3.3YC5-TR; SOT-353_SC-70-5

Connections:
+3V3: C2.1, JP1.1 (A), U2.5 (VOUT)
+5V: C1.1, C4.1, J2.2, JP1.3 (B), U1.1 (VCCA), U2.1 (VIN), U2.3 (EN)
/PMOD0: J3.1, R1.2
/PMOD1: J3.2, R2.2
/PMOD2: J3.3, R3.2
/PMOD3: J3.4, R4.2
/PMOD4: J3.7, R5.2
/PMOD5: J3.8, R6.2
/PMOD6: J3.9, R7.2
/PMOD7: J3.10, R8.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, J2.1, J3.5, J3.11, U1.10 (GND), U1.11 (~OE), U1.21 (GND), U2.2 (GND)
unnamed: J1.1, U1.9 (A7)
unnamed: J1.2, U1.8 (A6)
unnamed: J1.3, U1.7 (A5)
unnamed: J1.4, U1.6 (A4)
unnamed: J1.5, U1.5 (A3)
unnamed: J1.6, U1.4 (A2)
unnamed: J1.7, U1.3 (A1)
unnamed: J1.8, U1.2 (A0)
unnamed: R1.1, U1.19 (B0)
unnamed: R2.1, U1.18 (B1)
unnamed: R3.1, U1.17 (B2)
unnamed: R4.1, U1.16 (B3)
unnamed: R5.1, U1.15 (B4)
unnamed: R6.1, U1.14 (B5)
unnamed: R7.1, U1.13 (B6)
unnamed: R8.1, U1.12 (B7)
V_{PMOD}: C3.1, C5.1, J3.6, J3.12, JP1.2 (C), U1.20 (VCCB)

Notes on the sheet:
Power Input
Note: pins are out of order for routing purposes
All resistors below are 200Ω
Connects to CAN Module
PMOD Voltage Selection
Level Shifter & Connectors
~{OE} low -> Normal Operation
5V to 3.3V Conversion
PMOD Connector

Board: 2 copper layers, 23.7 x 19.1 mm, 19 parts (3 on the bottom side), 28 nets.

## KiCad design accelerometer-board/accelerometer-board.kicad_pcb

File accelerometer-board/README.md:

# Accelerometer Board
This board features an BMI323 inertial measurement unit w/ a 6-axis accelerometer.
It is meant to be a daughterboard for the [CAN Module](../can-module) and is able to mount to the sensor interface and be attached with 2x M2 mounting screws.
The board also features a 5V <=> 3.3V logic level converter to allow for communication between the CAN Module and the IMU.

## Schematic
Screenshot of schematic is below. Higher-quality pdf available [here](assets/schematic.pdf)

## Pins
| CAN Module | Accelerometer Board |
| ---------- | ------------------- |
| A4         | N/C                 |
| A5         | N/C                 |
| A6         | SCL                 |
| A7         | SDA                 |
| A8         | Interrupt 1         |
| A9         | Interrupt 2         |
| A10        | N/C                 |
| A11        | N/C                 |

Parts:
C1, C2, C7, C8: 100n; C_0402_1005Metric
C9, C10: 1u; C_0402_1005Metric
J1: Conn_01x08; PinSocket_1x08_P1.00mm_Vertical
J2: Conn_01x02; PinSocket_1x02_P1.00mm_Vertical
R5, R6, R7, R8: 4k7; R_0402_1005Metric
U1: BMI323; BMI323_BOS
U2: FXMAR2104UMX; ULTRATHIN_MLP_12L_ONS
U6: MIC5365-3.3YC5-TR; SOT-353_SC-70-5

Connections:
+3V3: C1.1, C2.1, C8.1, C10.1, R7.1, R8.1, U1.5 (VDDIO), U1.8 (VDD), U1.12 (CSB), U2.1 (VCCB), U6.5 (VOUT)
+5V: C7.1, C9.1, J2.2, R5.1, R6.1, U2.2 (VCCA), U2.8 (OE), U6.1 (VIN), U6.3 (EN)
/IMU_INT1_3V3: U1.4 (INT1), U2.10 (B2)
/IMU_INT1_5V: J1.4, U2.5 (A2)
/IMU_INT2_3V3: U1.9 (INT2), U2.9 (B3)
/IMU_INT2_5V: J1.3, U2.6 (A3)
/SCL_3V3: R7.2, U1.13 (SCX), U2.12 (B0)
/SCL_5V: J1.6, R6.2, U2.3 (A0)
/SDA_3V3: R8.2, U1.14 (SDX), U2.11 (B1)
/SDA_5V: J1.5, R5.2, U2.4 (A1)
GND: C1.2, C2.2, C7.2, C8.2, C9.2, C10.2, J2.1, U1.1 (SDO), U1.6 (GNDIO), U1.7 (GND), U2.7 (GND), U6.2 (GND)

Notes on the sheet:
Inertial Measurement Unit (IMU)
5V <=> 3.3V Level Shifter
5V -> 3.3V Regulator
GPIO
Power Input

Board: 2 copper layers, 25.4 x 19.0 mm, 15 parts (2 on the bottom side), 11 nets.

## KiCad design power-can-tap/power-can-tap.kicad_pcb

Parts:
J1: Conn_01x04_Pin; 01x04_1mm
J2, J3: Conn_01x04_Socket; PinSocket_1x04_P2.54mm_Vertical

Connections:
+5V: J1.1, J2.1, J3.1
/CANH: J1.3, J2.3, J3.3
/CANL: J1.4, J2.4, J3.4
GND: J1.2, J2.2, J3.2

Notes on the sheet:
T-Tap

Board: 2 copper layers, 19.5 x 18.0 mm, 3 parts (0 on the bottom side), 4 nets.

## KiCad design can-module/can-module.kicad_pcb

File can-module/README.md:

# CAN Module
The CAN Module is the main building block for the overall Data Acquisition system.
It is used as an interface between the shared [CAN Bus](https://en.wikipedia.org/wiki/CAN_bus) and each individual sensor or module around the vehicle.
This document holds all documentation about the components and usage for the CAN Module PCB.

See the [software](software) and [pcb](pcb) directories for more info on the respective topics.

Parts:
C1, C2, C3, C4, C12: 10u; C_0402_1005Metric
C5, C6, C7, C8, C9, C10, C11: 100n; C_0402_1005Metric
D1, D2, D3: PESD5V0S1BAF; D_SOD-323
IC1: PIC32CM1216JH01048-I_U5B; QFN50P700X700X90-49N-D; Manufacturer_Part_Number PIC32CM1216JH01048-I/U5B
J1: Conn_01x08_Socket; Untitled
J3: Conn_01x04_Socket; 01x04_1mm
JP2: Jumper_2_Small_Open; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
R1: 100k; R_0402_1005Metric
R2: 1k; R_0402_1005Metric
R3: 120; R_0402_1005Metric
TP3, TP4: TestPoint; TestPoint_Pad_D1.0mm
U1: ATA6560-GBQW-N; VDFN8_3X3_MCH

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C11.1, C12.1, D1.2 (A2), IC1.6 (AVDD), IC1.17 (VDDIO_1), IC1.36 (VDDIO_2), IC1.43 (VDDCORE), IC1.44 (VDDIN), J3.4, R1.1, R2.2, U1.3 (VCC); also elsewhere on the board
CANH: D2.2 (A2), J3.2, JP2.1 (A), U1.7 (CANH)
CANL: D3.2 (A2), J3.1, R3.1, U1.6 (CANL)
CAN_NSIL: IC1.32 (PA23), U1.5 (NSIL)
CAN_RX: IC1.34 (PA25), U1.4 (RXD)
CAN_STBY: IC1.31 (PA22), U1.8 (STBY)
CAN_TX: IC1.33 (PA24), U1.1 (TXD)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, D1.1 (A1), D2.1 (A1), D3.1 (A1), IC1.5 (AVSS), IC1.18 (GND_1), IC1.35 (GND_2), IC1.42 (GND_3), IC1.49 (EP), J3.3, U1.2 (GND), U1.9 (EPAD); also elsewhere on the board
unnamed: IC1.45 (PA30_SWCLK), R2.1, TP4.1
unnamed: IC1.46 (PA31_SWDIO), TP3.1
unnamed: C10.1, IC1.40 (~RESET), R1.2
unnamed: JP2.2 (B), R3.2
PA02: IC1.3 (PA02), J1.8; also elsewhere on the board
PA03: IC1.4 (PA03), J1.7; also elsewhere on the board
PA04: IC1.9 (PA04), J1.6; also elsewhere on the board
PA05: IC1.10 (PA05), J1.5; also elsewhere on the board
PA06: IC1.11 (PA06), J1.4; also elsewhere on the board
PA07: IC1.12 (PA07), J1.3; also elsewhere on the board
PA08: IC1.13 (PA08), J1.2; also elsewhere on the board
PA09: IC1.14 (PA09), J1.1; also elsewhere on the board

Notes on the sheet:
1x decoupling cap for each power pin
Main connector
Decoupling Capacitors
GPIO Header
CAN Transceiver
1x bulk cap for each AVDD, VDDIO, VDDIN, VDDCORE
PIC32 MCU
*All TVS diodes are PESD5V0S1BAF unless otherwise noted

Parts:
JP1, JP3, JP4, JP5, JP6, JP7, JP8, JP9: SolderJumper_3_Open; Jumper3Small
R4, R5, R6, R7, R8, R9, R10, R11: 1k; R_0402_1005Metric

Connections:
+5V: JP1.3 (B), JP3.3 (B), JP4.3 (B), JP5.3 (B), JP6.3 (B), JP7.3 (B), JP8.3 (B), JP9.3 (B); also elsewhere on the board
GND: JP1.1 (A), JP3.1 (A), JP4.1 (A), JP5.1 (A), JP6.1 (A), JP7.1 (A), JP8.1 (A), JP9.1 (A); also elsewhere on the board
unnamed: JP1.2 (C), R4.2
unnamed: JP3.2 (C), R5.2
unnamed: JP4.2 (C), R6.2
unnamed: JP5.2 (C), R7.2
unnamed: JP6.2 (C), R8.2
unnamed: JP7.2 (C), R9.2
unnamed: JP8.2 (C), R10.2
unnamed: JP9.2 (C), R11.2
PA02: R5.1; also elsewhere on the board
PA03: R4.1; also elsewhere on the board
PA04: R6.1; also elsewhere on the board
PA05: R7.1; also elsewhere on the board
PA06: R8.1; also elsewhere on the board
PA07: R9.1; also elsewhere on the board
PA08: R10.1; also elsewhere on the board
PA09: R11.1; also elsewhere on the board

Notes on the sheet:
GPIO Pull Up/Down Resistors

Board: 2 copper layers, 25.4 x 19.1 mm, 41 parts (10 on the bottom side), 28 nets.
