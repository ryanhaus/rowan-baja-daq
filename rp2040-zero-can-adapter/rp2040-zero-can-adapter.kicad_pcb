# Repository ryanhaus/rowan-baja-daq (continued)

## KiCad design main_unit/hardware/main_unit.kicad_pcb

Parts:
C17, C18: 2u2; C_0603_1608Metric
C19, C20: 1u; C_0603_1608Metric
C21: 100n; C_0402_1005Metric
C22, C23: 18p; C_0201_0603Metric
C24, C25: 7p; C_0201_0603Metric
R1: 10k; R_0402_1005Metric
SW1: PTS636SM43SMTR LFS; SW_Tactile_SPST_NO_Straight_CK_PTS636Sx25SMTRLFS
U1: STM32H753ZIT6; LQFP-144_20x20mm_P0.5mm
Y1: ABM8G-25.000MHZ-18-D2Y-T; Crystal_SMD_Abracon_ABM8G-4Pin_3.2x2.5mm
Y2: SC32S-7PF20PPM; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
+3V3: C19.1, C20.1, U1.6 (VBAT), U1.17 (VDD), U1.30 (VDD), U1.33 (VDDA), U1.39 (VDD), U1.52 (VDD), U1.62 (VDD), U1.72 (VDD), U1.84 (VDD), U1.95 (VDD33_USB), U1.108 (VDD), U1.121 (VDD), U1.131 (VDD), U1.144 (VDD); also elsewhere on the board
CAN_RX: U1.103 (PA11); also elsewhere on the board
CAN_STANDBY: U1.101 (PA9); also elsewhere on the board
CAN_TX: U1.104 (PA12); also elsewhere on the board
DBG_JTDO_SWO: U1.133 (PB3)
DBG_JTMS_JTDI: U1.110 (PA15); also elsewhere on the board
DBG_JTMS_SWCLK: U1.109 (PA14)
DBG_JTMS_SWDIO: U1.105 (PA13)
GND: C17.2, C18.2, C19.2, C20.2, C21.1, C22.2, C23.2, C24.1, C25.1, R1.2, SW1.2 (B), U1.16 (VSS), U1.31 (VSSA), U1.38 (VSS), U1.51 (VSS), U1.61 (VSS), U1.83 (VSS), U1.94 (VSS), U1.107 (VSS), U1.120 (VSS), U1.130 (VSS), Y1.2, Y1.4; also elsewhere on the board
LCDSPI_SCK: U1.126 (PG11); also elsewhere on the board
LCDSPI_SDA: U1.123 (PD7); also elsewhere on the board
LCD_B0: U1.3 (PE4)
LCD_B1: U1.127 (PG12)
LCD_B2: U1.122 (PD6); also elsewhere on the board
LCD_B3: U1.100 (PA8); also elsewhere on the board
LCD_B4: U1.102 (PA10); also elsewhere on the board
LCD_B5: U1.37 (PA3); also elsewhere on the board
LCD_B6: U1.139 (PB8); also elsewhere on the board
LCD_B7: U1.140 (PB9); also elsewhere on the board
LCD_CLK: U1.92 (PG7); also elsewhere on the board
LCD_CS: U1.124 (PG9); also elsewhere on the board
LCD_DE: U1.22 (PF10); also elsewhere on the board
LCD_G0: U1.4 (PE5)
LCD_G1: U1.5 (PE6)
LCD_G2: U1.42 (PA6); also elsewhere on the board
LCD_G3: U1.125 (PG10); also elsewhere on the board
LCD_G4: U1.69 (PB10); also elsewhere on the board
LCD_G5: U1.70 (PB11); also elsewhere on the board
LCD_G6: U1.97 (PC7); also elsewhere on the board
LCD_G7: U1.117 (PD3); also elsewhere on the board
LCD_HSYNC: U1.96 (PC6); also elsewhere on the board
LCD_R0: U1.128 (PG13)
LCD_R1: U1.36 (PA2)
LCD_R2: U1.35 (PA1); also elsewhere on the board
LCD_R3: U1.46 (PB0); also elsewhere on the board
LCD_R4: U1.41 (PA5); also elsewhere on the board
LCD_R5: U1.26 (PC0); also elsewhere on the board
LCD_R6: U1.47 (PB1); also elsewhere on the board
LCD_R7: U1.91 (PG6); also elsewhere on the board
LCD_RST: U1.129 (PG14); also elsewhere on the board
LCD_VSYNC: U1.40 (PA4); also elsewhere on the board
LEDCTRL_DIM_PWM: U1.136 (PB6); also elsewhere on the board
LEDCTRL_FAULT: U1.137 (PB7); also elsewhere on the board
NRST: C21.2, SW1.1 (A), U1.25 (NRST); also elsewhere on the board
unnamed: C17.1, U1.71 (VCAP)
unnamed: C18.1, U1.106 (VCAP)
unnamed: R1.1, U1.138 (BOOT0)
unnamed: C24.2, U1.8 (PC14), Y2.1
unnamed: C25.2, U1.9 (PC15), Y2.2
unnamed: C22.1, U1.23 (PH0), Y1.1
unnamed: C23.1, U1.24 (PH1), Y1.3
SDMMC_CLK: U1.113 (PC12)
SDMMC_CMD: U1.116 (PD2)
SDMMC_D0: U1.98 (PC8)
SDMMC_D1: U1.99 (PC9)
SDMMC_D2: U1.111 (PC10)
SDMMC_D3: U1.112 (PC11)
SDRAM_A0: U1.10 (PF0); also elsewhere on the board
SDRAM_A1: U1.11 (PF1); also elsewhere on the board
SDRAM_A2: U1.12 (PF2); also elsewhere on the board
SDRAM_A3: U1.13 (PF3); also elsewhere on the board
SDRAM_A4: U1.14 (PF4); also elsewhere on the board
SDRAM_A5: U1.15 (PF5); also elsewhere on the board
SDRAM_A6: U1.50 (PF12); also elsewhere on the board
SDRAM_A7: U1.53 (PF13); also elsewhere on the board
SDRAM_A8: U1.54 (PF14); also elsewhere on the board
SDRAM_A9: U1.55 (PF15); also elsewhere on the board
SDRAM_A10: U1.56 (PG0); also elsewhere on the board
SDRAM_A11: U1.57 (PG1); also elsewhere on the board
SDRAM_BA0: U1.89 (PG4); also elsewhere on the board
SDRAM_BA1: U1.90 (PG5); also elsewhere on the board
SDRAM_D0: U1.85 (PD14); also elsewhere on the board
SDRAM_D1: U1.86 (PD15); also elsewhere on the board
SDRAM_D2: U1.114 (PD0); also elsewhere on the board
SDRAM_D3: U1.115 (PD1); also elsewhere on the board
SDRAM_D4: U1.58 (PE7); also elsewhere on the board
SDRAM_D5: U1.59 (PE8); also elsewhere on the board
SDRAM_D6: U1.60 (PE9); also elsewhere on the board
SDRAM_D7: U1.63 (PE10); also elsewhere on the board
SDRAM_D8: U1.64 (PE11); also elsewhere on the board
SDRAM_D9: U1.65 (PE12); also elsewhere on the board
SDRAM_D10: U1.66 (PE13); also elsewhere on the board
SDRAM_D11: U1.67 (PE14); also elsewhere on the board
SDRAM_D12: U1.68 (PE15); also elsewhere on the board
SDRAM_D13: U1.77 (PD8); also elsewhere on the board
SDRAM_D14: U1.78 (PD9); also elsewhere on the board
SDRAM_D15: U1.79 (PD10); also elsewhere on the board
SDRAM_NBL0: U1.141 (PE0); also elsewhere on the board
SDRAM_NBL1: U1.142 (PE1); also elsewhere on the board
SDRAM_SDCKE0: U1.29 (PC3_C); also elsewhere on the board
SDRAM_SDCLK: U1.93 (PG8); also elsewhere on the board
SDRAM_SDNCAS: U1.132 (PG15); also elsewhere on the board
SDRAM_SDNE0: U1.28 (PC2_C); also elsewhere on the board
SDRAM_SDNRAS: U1.49 (PF11); also elsewhere on the board
SDRAM_SDNWE: U1.43 (PA7); also elsewhere on the board
UART_RX: U1.73 (PB12); also elsewhere on the board
UART_TX: U1.74 (PB13); also elsewhere on the board

Notes on the sheet:
1x bulk cap for VDD 1x bulk cap for VDDA

Parts:
D5: DF2S5.6FS,L3M
J2: Conn_02x07_Odd_Even; SAMTEC_FTSH-107-01-L-DV-K-A

Connections:
/CANBus/CANH: D5.2 (A2); also elsewhere on the board
DBG_JTMS_JTDI: J2.10; also elsewhere on the board
GND: D5.1 (A1), J2.5, J2.7, J2.11; also elsewhere on the board
NRST: J2.12; also elsewhere on the board
UART_RX: J2.13; also elsewhere on the board
UART_TX: J2.14; also elsewhere on the board

Notes on the sheet:
ST-Link

Parts:
C48: 100n; C_0402_1005Metric
D5, D6: D5V0H1B2LP-7B; D_0402_1005Metric
J4: 691137710002
R5: 120; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U5: ATA6561-GAQW-N; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: U5.5 (VIO); also elsewhere on the board
+5V: C48.1, U5.3 (VCC); also elsewhere on the board
/CANBus/CANH: D5.2 (A2), J4.2, R5.1, U5.7 (CANH)
/CANBus/CANL: D6.2 (A2), J4.1, R5.2, U5.6 (CANL)
CAN_RX: U5.4 (RXD); also elsewhere on the board
CAN_STANDBY: U5.8 (STBY); also elsewhere on the board
CAN_TX: U5.1 (TXD); also elsewhere on the board
GND: C48.2, D5.1 (A1), D6.1 (A1), U5.2 (GND); also elsewhere on the board

Notes on the sheet:
CANBus Terminal Block
CANBus Transceiver

Parts:
C26, C28, C29, C30, C31, C32, C33: 100n; C_0402_1005Metric
C27: 1u; C_0603_1608Metric
U3: W9864G6KH-6; SOP80P1176X120-54N; PARTREV A02

Connections:
+3V3: C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, U3.1 (VDD), U3.3 (VDDQ), U3.9 (VDDQ__1), U3.14 (VDD__1), U3.27 (VDD__2), U3.43 (VDDQ__2), U3.49 (VDDQ__3); also elsewhere on the board
GND: C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, U3.6 (VSSQ), U3.12 (VSSQ__1), U3.28 (VSS), U3.41 (VSS__1), U3.46 (VSSQ__2), U3.52 (VSSQ__3), U3.54 (VSS__2); also elsewhere on the board
SDRAM_A0: U3.23 (A0); also elsewhere on the board
SDRAM_A1: U3.24 (A1); also elsewhere on the board
SDRAM_A2: U3.25 (A2); also elsewhere on the board
SDRAM_A3: U3.26 (A3); also elsewhere on the board
SDRAM_A4: U3.29 (A4); also elsewhere on the board
SDRAM_A5: U3.30 (A5); also elsewhere on the board
SDRAM_A6: U3.31 (A6); also elsewhere on the board
SDRAM_A7: U3.32 (A7); also elsewhere on the board
SDRAM_A8: U3.33 (A8); also elsewhere on the board
SDRAM_A9: U3.34 (A9); also elsewhere on the board
SDRAM_A10: U3.22 (A10/AP); also elsewhere on the board
SDRAM_A11: U3.35 (A11); also elsewhere on the board
SDRAM_BA0: U3.20 (BS0); also elsewhere on the board
SDRAM_BA1: U3.21 (BS1); also elsewhere on the board
SDRAM_D0: U3.2 (DQ0); also elsewhere on the board
SDRAM_D1: U3.4 (DQ1); also elsewhere on the board
SDRAM_D2: U3.5 (DQ2); also elsewhere on the board
SDRAM_D3: U3.7 (DQ3); also elsewhere on the board
SDRAM_D4: U3.8 (DQ4); also elsewhere on the board
SDRAM_D5: U3.10 (DQ5); also elsewhere on the board
SDRAM_D6: U3.11 (DQ6); also elsewhere on the board
SDRAM_D7: U3.13 (DQ7); also elsewhere on the board
SDRAM_D8: U3.42 (DQ8); also elsewhere on the board
SDRAM_D9: U3.44 (DQ9); also elsewhere on the board
SDRAM_D10: U3.45 (DQ10); also elsewhere on the board
SDRAM_D11: U3.47 (DQ11); also elsewhere on the board
SDRAM_D12: U3.48 (DQ12); also elsewhere on the board
SDRAM_D13: U3.50 (DQ13); also elsewhere on the board
SDRAM_D14: U3.51 (DQ14); also elsewhere on the board
SDRAM_D15: U3.53 (DQ15); also elsewhere on the board
SDRAM_NBL0: U3.15 (LDQM); also elsewhere on the board
SDRAM_NBL1: U3.39 (UDQM); also elsewhere on the board
SDRAM_SDCKE0: U3.37 (CKE); also elsewhere on the board
SDRAM_SDCLK: U3.38 (CLK); also elsewhere on the board
SDRAM_SDNCAS: U3.17 (~CAS); also elsewhere on the board
SDRAM_SDNE0: U3.19 (~CS); also elsewhere on the board
SDRAM_SDNRAS: U3.18 (~RAS); also elsewhere on the board
SDRAM_SDNWE: U3.16 (~WE); also elsewhere on the board

Parts:
C1, C2: 10u; C_0805_2012Metric
C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16: 100n; C_0402_1005Metric
C47: 47u; WCAP-ASLI_5X5.5_DXL_
D4: D5V0H1B2LP-7B; D_0402_1005Metric
J3: 691137710002
U2: LD39200PU33R; SON95P300X300X100-7N; PARTREV 3

Connections:
+3V3: C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, U2.1 (OUT), U2.2 (SENSE); also elsewhere on the board
+5V: C1.1, C47.1, D4.2 (A2), J3.2, U2.5 (EN), U2.6 (IN); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C47.2, D4.1 (A1), J3.1, U2.3 (GND), U2.7 (EXP); also elsewhere on the board

Notes on the sheet:
STM32 Decoupling Capacitors
14x decoupling cap, 1 per VDD pin bulk caps on parent sheet
Input Power Filtering
5V to 3.3V Regulator
Input Power Connector

Parts:
C34, C38: 1u; C_0603_1608Metric
C35, C36, C39, C44: 100n; C_0402_1005Metric
C37: 2u2; C_0603_1608Metric
C40: 1u; C_0805_2012Metric
C41: 10u; C_0603_1608Metric
C42, C43: 47u; WCAP-ASLI_5X5.5_DXL_
C45: 2n7; C_0201_0603Metric
C46: 47p; C_0201_0603Metric
D1, D2, D3: BAT54T1G; D_SOD-123
J1: 62684-402100ALF; AMPHENOL_62684-402100ALF; PARTREV AK
L1: 22u; L_Taiyo-Yuden_NR-40xx
Q1: 2N7002BK,215; SOT-23-3
R2, R3, R4, R8, R10, R12, R13, R14, R15: 10k; R_0402_1005Metric
R7, R9: 15k; R_0402_1005Metric
R11: 1k; R_0402_1005Metric
U4: MAX25512ATG/V+T; WQFN-24-1EP_4x4mm_P0.5mm_EP2.45x2.45mm_ThermalVias

Connections:
+3V3: C34.1, C35.1, J1.05, R2.1, R3.1, R4.1; also elsewhere on the board
+5V: C36.1, C37.1, Q1.1 (D), U4.3 (IN), U4.24 (EN); also elsewhere on the board
/Display/BACKLIGHT_ANODE: C41.1, C43.1, C44.1, D1.1 (K), J1.01, R10.1
/Display/BACKLIGHT_CATHODE: J1.02, J1.03, R15.1, U4.11 (OUT1)
/Display/V18: C38.1, C39.1, U4.8 (RSDT), U4.9 (V18), U4.14 (TEMP)
GND: C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, D2.2 (A), J1.04, J1.34, J1.40, J1.S1 (SHIELD), J1.S2 (SHIELD__1), R7.2, R9.2, R11.2, R12.2, R13.2, R14.2, R15.2, U4.10 (GND), U4.15 (LEDGND), U4.22 (PGND), U4.23 (PGND), U4.25 (EP); also elsewhere on the board
LCDSPI_SCK: J1.10; also elsewhere on the board
LCDSPI_SDA: J1.09; also elsewhere on the board
LCD_B2: J1.16; also elsewhere on the board
LCD_B3: J1.17; also elsewhere on the board
LCD_B4: J1.18; also elsewhere on the board
LCD_B5: J1.19; also elsewhere on the board
LCD_B6: J1.20; also elsewhere on the board
LCD_B7: J1.21; also elsewhere on the board
LCD_CLK: J1.12; also elsewhere on the board
LCD_CS: J1.11; also elsewhere on the board
LCD_DE: J1.13; also elsewhere on the board
LCD_G2: J1.22; also elsewhere on the board
LCD_G3: J1.23; also elsewhere on the board
LCD_G4: J1.24; also elsewhere on the board
LCD_G5: J1.25; also elsewhere on the board
LCD_G6: J1.26; also elsewhere on the board
LCD_G7: J1.27; also elsewhere on the board
LCD_HSYNC: J1.15; also elsewhere on the board
LCD_R2: J1.28; also elsewhere on the board
LCD_R3: J1.29; also elsewhere on the board
LCD_R4: J1.30; also elsewhere on the board
LCD_R5: J1.31; also elsewhere on the board
LCD_R6: J1.32; also elsewhere on the board
LCD_R7: J1.33; also elsewhere on the board
LCD_RST: J1.06; also elsewhere on the board
LCD_VSYNC: J1.14; also elsewhere on the board
LEDCTRL_DIM_PWM: U4.17 (DIM); also elsewhere on the board
LEDCTRL_FAULT: R2.2, U4.16 (FLTB); also elsewhere on the board
LEDCTRL_SCL: R3.2, U4.19 (SCL)
LEDCTRL_SDA: R4.2, U4.18 (SDA)
unnamed: C40.1, R8.2
unnamed: D1.2 (A), L1.2, U4.1 (DRAIN), U4.2 (DRAIN)
unnamed: C42.1, D2.1 (K), D3.2 (A), L1.1, Q1.3 (S)
unnamed: D3.1 (K), Q1.2 (G), U4.4 (NGATE)
unnamed: C46.1, R10.2, R11.1, U4.5 (BSTMON)
unnamed: C45.1, R8.1, U4.7 (COMP)
unnamed: R9.1, U4.13 (ISET)
unnamed: R14.1, U4.12 (OUT2)
unnamed: R13.1, U4.20 (OUT3)
unnamed: R12.1, U4.21 (OUT4)
unnamed: R7.1, U4.6 (RT)

Notes on the sheet:
15k -> 1.76MHz
Display Connector
P/N: 865080342006
Backlight Boost Converter & Driver
V_{OUT_BSTMON} = 0.95*(1+10k/1k) = 10.45V
Display: ER-TFT062-1 Datasheet: https://www.buydisplay.com/download/manual/ER-TFT062-1_Datasheet.pdf Purchase: https://www.buydisplay.com/bar-type-6-2-inch-360x960-ips-tft-lcd-display-spi-rgb-interface
Min inductance: ~11uH Min current: 330mA See "Applications Information" in datasheet Part chosen: NRS4018T220MDGJ
R_{SET} = 1500/0.1A = 15k

Board: 4 copper layers, 75.0 x 65.0 mm, 82 parts (0 on the bottom side), 101 nets.

## Commit log (part)

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2025-09-11 main_unit/software: Add to repo (copied from sandbox/zephyr/lvgl-threads)
2025-09-11 main_unit/software: Add README
2025-09-11 main_unit/software: Add .gitignore to ignore Zephyr build files
2025-09-16 main_unit/hardware: Add STM32H753ZIT6 MCU to schematic
2025-09-16 main_unit/hardware: Add in capacitors
2025-09-17 main_unit/hardware: Connect pull down resistor to BOOT0
2025-09-17 main_unit/hardware: Add in 25MHz crystal oscillator and capacitors
2025-09-18 main_unit/hardware: Fix STM32 to use LQFP-144 package instead of LQFP-100
2025-09-18 main_unit/hardware: Add PCB to project with STM32 decoupling & bulk capacitors in rough positions
2025-09-18 main_unit/hardware: Position VCAP capacitors
2025-09-18 main_unit/hardware: Assign all pins for STM32
2025-09-18 main_unit/hardware: Add in empty sheets for display, SDRAM, and debug
2025-09-18 main_unit/hardware: Add in missing byte enable pins for SDRAM
2025-09-18 main_unit/hardware: Add in capacitors for SDRAM chip
2025-09-18 main_unit/hardware: Add in display connector, expand LTDC to RGB888 (fixes pin error)
2025-09-18 main_unit/hardware: Add capacitors for display
2025-09-19 main_unit/hardware: Fill out LED driver component values except for compensation circuit
2025-09-20 main_unit/hardware: Fill in compensation circuit values
2025-09-20 main_unit/hardware: Change reset button type
2025-09-22 main_unit/hardware: Connect LCD controller FAULT and PWM pin to STM32
2025-09-23 main_unit/hardware: Rearrange components in boost converter to minimize loop area
2025-09-23 main_unit/hardware: Add in input power filtering and ST-Link connector
2025-09-24 main_unit/hardware: Add more TVS diodes
2025-09-25 main_unit/hardware: Rearrange more components, add CAN transceiver
2025-09-25 main_unit/hardware: Set up board as 4-layer, add ground and power planes
2025-09-25 main_unit/hardware: More routing, specifically for CAN and decoupling caps
2025-09-25 main_unit/hardware: Route out SDRAM (without length matching)
2025-09-29 main_unit/hardware: Keep trying to find good way of routing out display
2025-09-30 main_unit/hardware: Route LCD pins to vias
2025-09-30 can-module: Add PIC32 mcu library to project
2025-09-30 can-module: Add decoupling capacitors for mcu
2025-09-30 can-module: Route power, gnd, and swd pins to test points
2025-10-02 can-module: Add components to pcb
2025-10-02 can-module: Add ATA6560 CAN transceiver
2025-10-04 can-module: Add in JLCPCB constraints
2025-10-04 can-module: Add power and gnd planes
2025-10-07 can-module: Fix ATA6560 footprint to have 3D model
2025-10-07 can-module: Route out all signals
2025-10-09 can-module: Rearrange components, update constraints for copper to board edge
2025-10-09 can-module: Change connector footprints, add silkscreen labels
2025-10-09 can-module: Fix ground via pattern under ATA6560
2025-10-09 can-module: Add text labels to schematic
2025-10-09 can-module: Move around capacitors for PIC32
2025-10-09 can-module: Extend 5V bar going to AVDD
2025-10-09 can-module: Move around traces to maximize power plane area
2025-10-13 can-module: Finalize pcb layout, fix errors and constraints
2025-10-13 can-module: Update board layout to have 3x M2.5 screw holes
2025-10-13 can-module: Comply with JLCPCB's via restrictions to avoid extra charges
2025-10-13 can-module: Add back M2 mounting holes, finalize layout
2025-10-14 can-module: Add SWD pins back in
2025-10-14 can-module: Convert GPIO header from 2x 4pin header to 1x 8pin
2025-10-14 can-module: Update .gitignore to ignore production files
2025-10-15 can-module: Update PCB to match requirements for JLCPCB economic PCBA
2025-10-16 power-can-tap: Add to repo
2025-10-16 power-can-tap: Route out PCB
2025-10-20 can-module, power-can-tap: Ignore generated .step 3D model files
2025-10-23 can-module: Make simple CAD model for bottom of enclosure
2025-10-28 can-module: Remove CAD folder
2025-10-28 can-module: Add 5V output for daughter boards
2025-11-04 can-module: Adjust positioning for 5V daughterboard connector, add 3D models for daughterboard connector headers
2025-11-13 sd-card-board: Set up schematic
2025-11-13 sd-card-board: Swap components, get general placement of components on PCB done
2025-11-13 sd-card-board: Fix connector spacing
2025-11-13 sd-card-board: Fully fix positioning issues
2025-11-18 accelerometer-board: Add to repo, design and route out board
2025-11-20 comm-unit: Add to repo with board design
2025-11-25 comm-module: Rearrange components and redo traces
2025-11-29 can-module: Major changes to routing, placement; remove pull up/down resistors (use PIC32 internal resistors)
2025-11-29 can-module: Remove unused GPIO resistors sheet
2025-12-01 can-module: Update ESD diode component
2025-12-01 can-module: Change header size from 1mm spacing to 1.27mm spacing
2025-12-01 can-module: Re-attach gnd connection to main bulk cap for 5V
2025-12-01 can-module: Refill filled zones
2025-12-01 sd-card-board: Refill zones
2025-12-01 can-module: Update CAN/PWR header to also be 0.127mm, move some things around to allow for wider min power plane width
2025-12-01 can-module: Update text
2025-12-01 accelerometer-board: Update footprints
2025-12-01 comm-unit: Update headers to 1.27mm spacing
2026-01-20 Sync files
2026-01-20 head-unit: Update .gitignore to exclude KiCad cache files
2026-01-20 level-shifter: Add .gitignore
2026-01-20 level-shifter: Rename to pmod-adapter
2026-01-21 can-module: Finish updating CAN module
2026-01-21 pmod-adapter: Begin working on PMOD adapter PCB
2026-01-22 can-module: Add power LED and indicator LED
2026-02-10 can-module: Add more dimensions to User-1 layer
2026-02-10 can-module: Update sch info
2026-02-10 can-module: Update readme
2026-02-10 pmod-adapter: Update step output file
2026-02-10 can-module: Add needed asset for 'Connecting to Other Modules' section
2026-02-11 can-module: Decrease MCU and transceiver image sizes in README
2026-02-11 can-module: Update pin directionsn on CAN TX/RX on transceiver for clarity
2026-02-11 can-module: Add 10uF bulk capacitor on module power output pin
2026-02-12 can-module: Remove redundant dimensions and clean up dimensions of PCB
2026-02-12 pmod-adapter: Add README with images
2026-02-12 pmod-adapter: Fill out info on sch
2026-02-12 pmod-adapter: Add schematic to README
2026-02-12 accelerometer-board: Move KiCad files into pcb directory
2026-02-12 accelerometer-board: Ensure consistent component styling
2026-02-12 accelerometer-board: Add README
2026-02-12 comm-unit: Move KiCad files into pcb directory
2026-02-12 comm-unit: Fill out info in sch
2026-02-12 comm-unit: Add README
2026-02-12 comm-unit: Label correct pin numbers on README
2026-02-12 sd-card-board: Move all KiCad files into pcb directory
2026-02-12 sd-card-board: Ensure consistent styling for schematic components
2026-02-12 sd-card-board: Fill out info on sch
2026-02-12 sd-card-board: Switch pins around to ensure that all SPI pins are connected to the same peripheral
2026-02-12 sd-card-board: Fix PCB, switch from using SERCOM0 to SERCOM2
2026-02-12 Add README
2026-02-12 can-module: Switch to using DESD5V0U1BA-7 TVS diodes
2026-02-14 can-module: Update schematic and PCB to fully add in power filtering components
2026-02-14 can-module: Update docs to reflect changes to board
2026-02-15 can-module: Add 1mm test point with tight spacing
2026-02-15 can-module: Use tight spacing test points on GPIO test points
2026-02-15 can-module: Swap ideal diode package to be a KiCad standard package
2026-02-16 can-module: Update documentation to reflect new test point changes
2026-02-16 can-module: Fix critical error bridging 5V to VDDCORE
2026-02-16 can-module: Re-link all PCB components by refdes
2026-02-16 can-module: Reassign all reference designators by geographical position on schematic
2026-02-17 can-module: Change programming header to be through hole for easier access
2026-02-17 can-module: Label the GPIO voltage selector resistor
2026-02-17 can-module: Update documentation to reflect changes
2026-02-18 can-module: Update info about GPIO power header on README, clarify that it is VDDIO not necessarily 5V
2026-02-18 can-module: Fix NOTE block in readme
2026-02-18 can-module: Remove blurb about changing SWD voltage
2026-02-18 can-module: Re-attach microcontroller GND pins to bottom plane
2026-02-19 can-module: Start using KiBot to auto generate 3D renders
2026-02-19 can-module: Update with KiBot-generated 3D renders
2026-02-19 can-module: Update KiBot to create pdf of schematic
2026-02-19 can-module: Configure Kibot to create svg of board dimensions
2026-02-19 can-module: Add labelled screenshots for README
2026-02-19 can-module: Update README to contain info about KiBot
2026-02-26 can-module/software: Switch to using CMake
2026-02-26 can-module/software: Add second target, use bin dir for cmake
2026-02-26 can-module/software: Move source files into 'src' directory
2026-02-26 can-module/software: Restructure software directory, add example library and targets dir
2026-02-26 can-module: Add extra note about 'cmake -B bin'
2026-02-27 can-module/software: Consolidate for readability
2026-02-27 can-module/software: Add testing framework and integration with CMake
2026-03-02 can-module/software: Add LIB_NAME var to library CMakeLists.txt template
2026-03-02 can-module/software: Formatting in top-level CMakeLists
2026-04-10 can-module/software: Add vendor/mplab directory with empty gpio_base project
2026-04-10 can-module/software: Configure gpio_base project pins to match CAN module
2026-04-11 can-module/software: Add CAN + SysTick to gpio_base from MPLAB, add CMake files to compile with vendor files linked, add simple blinky program (untested)
2026-04-11 can-module/software: Fix CMake to properly compile the program and generate the hex file for flashing
2026-04-11 can-module/software: Remove unneeded files for MPLAB projects, add gitignore to ignore these files in the future
2026-04-11 can-module/software: Add more notes about using MPLAB to README in vendor folder
2026-04-11 can-module/software: Change tests cmake config so that it is built with a native compiler to be simulated
2026-04-11 can-module/software: Add MPLAB X IDE requirement
2026-04-11 can-module/software: Clarify requirement for MPLAB X IDE
2026-04-12 can-module/software: Regenerate vendor files to allow for 1 Mbps CAN communication
2026-04-12 can-module/software: Add can-test target
2026-04-13 can-module/software: Add quickstart for Fedora linux
2026-04-13 can-module/software: Update wording about libcriterion on Fedora
2026-04-14 can-module/software: Update blurb about copying projects in MPLAB X IDE
2026-04-14 can-module/software: Add more info about creating new projects (required pins)
2026-04-14 can-module/software: Include additional instructions for configuring pins
2026-04-14 can-module/software: Add 'uart_base' project to vendor/mplab
2026-04-14 can-module/software: Remove auto-generated main.c file from MPLAB vendor libraries
2026-04-16 can-module/software: Add uart-test target
2026-04-16 can-module/software: Add info about enabling SysTick to README
2026-04-16 can-module/software: Use board_led library in existing targets for readability
2026-04-16 can-module/software: Remove useless targets and libraries
2026-04-16 can-module/software: Add note about enabling automatic bit timing calculations
2026-04-16 can-module/software: Add spi_base vendor library
2026-04-16 can-module/software: Add i2c_base library
2026-04-16 can-module/software: Add i2c-test target
2026-05-03 can-module/software: Overhaul CMake build process to support multiple targets
2026-05-03 can-module/software: Add new HAL libraries using new CMake architecture
2026-05-03 can-module/software: Update targets to use new HAL libraries
2026-05-03 can-module/software: Move HAL libraries to their own directory
2026-05-03 can-module/software: Update README to give more info on project structure
2026-05-03 can-module/software: Automatically search for MDFP packs
2026-05-03 can-module/software: Use 'build' as build directory instead of 'bin'
2026-05-03 can-module/software: Stop tracking & remove compile_commands.json
